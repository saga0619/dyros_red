Commit message: linking

File: dyros_red_description/robots/dyros_red_robot_mj_new.urdf (robot description, URDF)
Before this commit: robot dyros_red_description, 33 links, 32 joints
Links:
- removed link base_link
Joints:
- removed joint virtual
